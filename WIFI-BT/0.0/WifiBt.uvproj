# Keil uVision project WifiBt.uvproj, settings and files
target WifiBt (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: WifiBt
  c flags: Optimize=8 SizeSpeed=1
  c include: .\UserAPP
  group Startp
    ./: STARTUP.A51
  group Src
    ./UserAPP/: Config.c Data_Process.c Key_Scan.c Led_Display.c USART.c WifiBt.c BT_Control.c
  group Inc
    ./UserAPP/: Config.h Data_Process.h Key_Scan.h Led_Display.h TypeDef.h USART.h WifiBt.h BT_Control.h
