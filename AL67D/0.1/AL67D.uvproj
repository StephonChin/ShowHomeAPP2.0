# Keil uVision project AL67D.uvproj, settings and files
target AL673D (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: AL67D +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\PrivateInc;.\PublicInc
  group Start
    ./: STARTUP.A51
  group PrivateSrc
    ./PrivateSrc/: AL67D.c KeyScan.c Led_Display.c MCU_Config.c Motor.c Ntc_Msr.c
  group PrivateInc
    ./PrivateInc/: AL67D.h Key_Scan.h Led_Display.h MCU_Config.h Motor.h Ntc_Msr.h Type_Private.h
  group PublicSrc
    ./PublicSrc/: CSR1010.c Data_Process.c Flash_Prgrm.c Led_Class.c Timer_Ctrl.c BT_Control.c
  group PublicInc
    ./PublicInc/: CSR1010.h Data_Process.h Flash_Prgrm.h Led_Class.h Timer_Ctrl.h Type_Def.h BT_Control.h
