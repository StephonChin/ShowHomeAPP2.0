# Keil uVision project AL93.uvproj, settings and files
target AL93 (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: AL93 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Include
  group Start
    ./: STARTUP.A51
  group Source
    ./Source/: AL93.c Config.c CSR1010.c Data_Process.c Eprom.c Led_Display.c Timer_Motor.c
  group Include
    ./Include/: AL93.h Config.h Csr1010.h Data_Process.h Eprom.h Led_Display.h System.h Timer_Motor.h
