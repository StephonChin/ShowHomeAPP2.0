# Keil uVision project DisplayHouse.uvprojx, settings and files
target DisplayHouse (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: DisplayHouse +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\Include;.\FWLib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./Source/: DisplayHouse.c Config.c Data_Process.c Key.c Led_Class.c Show_1.c Show_2.c Show_3.c
  group Include
    ./Include/: DisplayHouse.h Config.h Data_Process.h Key.h Led_Class.h Show.h TypeDef.h stm32f10x_conf.h
  group FWLibSrc
    ./FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
  group FWLibInc
    ./FWLib/inc/: stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_tim.h
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
