# Keil uVision project Mini93Motor.uvproj, settings and files
target Mini93Motor (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: Mini93Motor +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User
  group StartUp
    ./: STARTUP.A51
  group User
    ./User/: Config.c Config.h TypeDef.h Mini93Motor.c MIni93Motor.h
